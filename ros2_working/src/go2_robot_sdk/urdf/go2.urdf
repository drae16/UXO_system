Commit message: Updated launch files, infrasturcture, lidar decoder and FSM

File: ros2_working/src/go2_robot_sdk/urdf/go2.urdf (robot description, URDF)
Before this commit: robot go2, 31 links, 30 joints
Joints:
- joint gps_joint: origin xyz=.30 .20 0 rpy=0 0 0 -> xyz=.25 .0 .15 rpy=0 0 0
